# IAR project PY25Q64HA.ewp, settings and files
configuration PY25Q64HA (ARM, debug)
  General.OGChipSelectEditMenu: STM32U375RG ST STM32U375RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U375xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32U3xx_HAL_Driver/Inc; ../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U3xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PY25Q64HA.hex
  ILINK.IlinkOutputFile: PY25Q64HA.out
  ILINK.IlinkIcfFile: stm32u375xx_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u375xx.s
  group Application/User/Core
    ../Core/Src/: main.c py25q64ha.c stm32u3xx_hal_msp.c stm32u3xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_icache.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c stm32u3xx_hal_xspi.c stm32u3xx_ll_dlyb.c
