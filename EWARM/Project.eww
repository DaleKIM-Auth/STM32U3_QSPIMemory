<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PY25Q64HA.ewp</path>
  </project>
  <batchBuild />
</workspace>
